# Keil uVision project Keypad.uvproj, settings and files
target Target 1 (MCS-51)
  device: DS5002FP Dallas Semiconductor
  cpu: IRAM(0-0x7F) XRAM(0-0x1FFFF) CLOCK(16000000)
  output: Keypad +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
